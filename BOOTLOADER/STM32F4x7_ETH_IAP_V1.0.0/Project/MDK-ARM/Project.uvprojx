# Keil uVision project Project.uvprojx, settings and files
target STM324xG_EVAL (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324xG_EVAL
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL
  c include: ..\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\Utilities\STM32_EVAL\Common;..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7;..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone;..\..\Utilities\Third_Party\FreeRTOS_v6.1.0\portable\EWARM\ARM_CM3;..\..\Utilities\Third_Party\FreeRTOS_v6.1.0\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../src/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group User
    ../src/: tftpserver.c flash_if.c httpserver.c main.c netconf.c stm32f4x7_eth_bsp.c
  group LwIP
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: ip_frag.c autoip.c icmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/: udp.c dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c tcp.c tcp_in.c tcp_out.c
    ../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../Utilities/Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_syscfg.c misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_rcc.c
  group STM32F4x7_ETH_Driver
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
